#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

include opensbi.inc

SRC_URI += "file://qemu-riscv64-rules"

SRC_URI[opensbi.sha256sum] = "8fcbce598a73acc2c7f7d5607d46b9d5107d3ecbede8f68f42631dcfc25ef2b2"
