#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "a9231a6c77c638fe96d7e5426ea7d5b9d8a00872aa23e1246d2203c83acb0810"
