#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "93f8d61b68d4e4b2d2a7f756e5e19839f320b539173f30874f2939ca8f37d39d"
