#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "83b2172ee00e0b1621c83567955c232488213d36486d77a8f90766f053b6f5de"
