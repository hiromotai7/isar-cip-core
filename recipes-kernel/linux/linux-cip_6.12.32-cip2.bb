#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2025
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "948b118eb9f36a881cf77e6a20e508362131bcebff6fa46353062ceb939a4d5e"
