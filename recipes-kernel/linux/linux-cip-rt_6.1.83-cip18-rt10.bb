#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "d0b66c7084dc64df2c7d0fce591467dae34a1dc5e8dad8d88b521a2f8c4b1cf2"
