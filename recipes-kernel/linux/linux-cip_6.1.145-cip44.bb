#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "9e701e770dcaae87736c8a442021eef7d57c09aa70ae093c20531d70fc94b089"
