#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "6ad2551a89b955c6c78145295675418f384136fe6e6e6ad07373af6209261af1"
