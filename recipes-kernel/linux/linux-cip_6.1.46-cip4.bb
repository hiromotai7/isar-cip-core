#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

KERNEL_DEFCONFIG_VERSION ?= "6.1.y-cip"

SRC_URI[sha256sum] = "691c4e52281e47d324c4c9b840cba7050e42147a05342ce4cfe1ece40fb9c27b"
