#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "5c82d799d5a24f97e00fdc6bdbcbf1b3cc66cf87f9c48f3192201d3d8b00c60e"
