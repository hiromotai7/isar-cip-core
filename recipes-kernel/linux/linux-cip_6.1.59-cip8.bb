#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "bb6e346dfd61f2ad36fbbcc3401cb5da6519ca1c9e0222096e86fab7c203bbb9"
