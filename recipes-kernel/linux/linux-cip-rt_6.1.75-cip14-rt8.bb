#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "5b03796de85dd71b0fc1c67ee0fb5071dae10f22c85ca7c502b5b21f141d16c3"
