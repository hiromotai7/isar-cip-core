#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "95f5529a116d6b8172ff53e387509363f06aa19c60ee7e07ea2366ff31f7cb70"
