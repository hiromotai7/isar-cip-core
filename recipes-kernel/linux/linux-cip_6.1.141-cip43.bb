#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "e7de47f1bb910da28a5d4fd4887757909f00850dd0cdc40f1731b5fa85a329b0"
