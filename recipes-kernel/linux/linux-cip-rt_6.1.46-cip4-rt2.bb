#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "29f926c8755a503baa3e34bb967437e230075c9d9798c22415248983e9f53666"
