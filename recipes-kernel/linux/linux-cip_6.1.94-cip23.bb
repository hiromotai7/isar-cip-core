#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "38c6f43cea9b703e979100c68169dd703f0fa04af7635ca01ffd1cd4efddcdc2"
