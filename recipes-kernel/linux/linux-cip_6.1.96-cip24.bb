#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "48649290e51a0651c286a108804d3474bb2cca7d7c285c24f5d543736929fdcc"
