#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

require linux-cip-common.inc

SRC_URI[sha256sum] = "5f6aceb0a5828a2828f63cbe9763857ca3cd136100f11e392c847659c353773d"
